# Keil uVision project ECE_424_Final_Project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECE_424_Final_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: C:\ti\TivaWare_C_Series-2.1.4.178\inc;C:\ti\TivaWare_C_Series-2.1.4.178\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c pulse_sensor.h pulse_sensor.c LCD.h LCD.c SysTick_Delay.c SysTick_Delay.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
